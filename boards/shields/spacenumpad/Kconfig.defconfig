## boards/shields/spacenumpad/Kconfig.defconfig
```kconfig
if SHIELD_SPACENUMPAD

# Name must be less than 16 characters long!
config ZMK_KEYBOARD_NAME
    default "SpaceNumpad"

endif
```
